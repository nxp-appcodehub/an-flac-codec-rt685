# IAR project FLAC_demo.ewp, settings and files
configuration HiFi_FLAC_TEST (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT685S_M33 NXP MIMXRT685S_M33
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: NDEBUG; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; BOOT_HEADER_ENABLE=1; CPU_MIMXRT685SFVKB_cm33; SDK_I2C_BASED_COMPONENT_USED=1; SD_ENABLED; MCUXPRESSO_SDK; FLAC__HAS_OGG=0; PACKAGE_VERSION="1.3.4"; HAVE_LROUND; HAVE_STDINT_H; FLAC_EMBEDDED; DSP_RUN; DSP_IMAGE_COPY_TO_RAM=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: board; source; CMSIS; MIMXRT685S; component/gpio; component/lists; component/osa; component/uart; device; drivers; evkmimxrt685/sdmmc_examples/sdcard_fatfs; fatfs/source; fatfs/source/fsl_sd_disk; flash_config; pmic_driver; sdmmc/host; sdmmc/inc; sdmmc/osa; utilities; libFLAC; libFLAC\include; libFLAC\include\share
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.ADefines: NDEBUG
  OBJCOPY.OOCOutputFile: sdk20-app.bin
  ILINK.IlinkOutputFile: FLAC_demo.out
  ILINK.IlinkConfigDefines: __heap_size__=0x2000; __stack_size__=0x2000
  ILINK.IlinkIcfFile: MIMXRT685S\iar\MIMXRT685Sxxxx_cm33_flash.icf
  ILINK.IlinkExtraOptions: --image_input=../../dsp/binary/dsp_text_release.bin,__dsp_text_bin,__dsp_text_section,4; --keep=__dsp_text_bin; --image_input=../../dsp/binary/dsp_data_release.bin,__dsp_data_bin,__dsp_data_section,4; --keep=__dsp_data_bin
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration CM33_FLAC_TEST (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT685SFVKB_cm33; BOOT_HEADER_ENABLE=1; SDK_I2C_BASED_COMPONENT_USED=1; SD_ENABLED; MCUXPRESSO_SDK; PACKAGE_VERSION="1.3.4"; HAVE_LROUND; FLAC__HAS_OGG=0; HAVE_STDINT_H; FLAC_EMBEDDED
  ILINK.IlinkConfigDefines: __heap_size__=0x80000; __stack_size__=0x2800
  ILINK.IlinkIcfFile: MIMXRT685S\iar\MIMXRT685Sxxxx_cm33_ram.icf
  group board
    board/: board.c board.h clock_config.c clock_config.h dsp_config.h dsp_support.c pin_mux.c pin_mux.h pmic_support.c sdmmc_config.c sdmmc_config.h
  group CMSIS
    CMSIS/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
  group component/gpio
    component/gpio/: fsl_adapter_gpio.h fsl_adapter_rt_gpio.c
  group component/lists
    component/lists/: fsl_component_generic_list.c fsl_component_generic_list.h
  group component/osa
    component/osa/: fsl_os_abstraction.h fsl_os_abstraction_bm.c fsl_os_abstraction_bm.h fsl_os_abstraction_config.h
  group component/uart
    component/uart/: fsl_adapter_uart.h fsl_adapter_usart.c
  group device
    device/: fsl_device_registers.h MIMXRT685S_cm33.h MIMXRT685S_cm33_features.h
  group doc
    doc/: readme.txt
  group drivers
    drivers/: fsl_cache.c fsl_cache.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_common_arm.c fsl_common_arm.h fsl_ctimer.c fsl_dsp.c fsl_flexcomm.c fsl_flexcomm.h fsl_flexspi.c fsl_flexspi.h fsl_gpio.c fsl_gpio.h fsl_i2c.c fsl_i2c.h fsl_iopctl.h fsl_mu.c fsl_ostimer.c fsl_ostimer.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_usart.c fsl_usart.h fsl_usdhc.c fsl_usdhc.h
  group dsp_binary
    ../../dsp/binary/: dsp_data_release.bin dsp_text_release.bin
  group fatfs/source
    fatfs/source/: diskio.c diskio.h ff.c ff.h ffsystem.c ffunicode.c
  group fatfs/source/fsl_sd_disk
    fatfs/source/fsl_sd_disk/: fsl_sd_disk.c fsl_sd_disk.h
  group flash_config
    flash_config/: flash_config.c flash_config.h
  group libFLAC
    libFLAC/: bitmath.c bitreader.c bitwriter.c cpu.c crc.c fixed.c format.c lpc.c md5.c memory.c metadata_object.c stream_decoder.c stream_encoder.c stream_encoder_framing.c window.c
  group MIMXRT685S
    MIMXRT685S/: system_MIMXRT685S_cm33.c system_MIMXRT685S_cm33.h
  group MIMXRT685S/iar
    MIMXRT685S/iar/: MIMXRT685Sxxxx_cm33_flash.icf MIMXRT685Sxxxx_cm33_ram.icf startup_MIMXRT685S_cm33.s
  group pmic_driver
    pmic_driver/: fsl_pca9420.c fsl_pca9420.h
  group sdmmc/host
    sdmmc/host/: ChangeLogKSDK.txt fsl_sdmmc_host.c fsl_sdmmc_host.h
  group sdmmc/inc
    sdmmc/inc/: fsl_sd.h fsl_sdmmc_common.h fsl_sdmmc_spec.h
  group sdmmc/osa
    sdmmc/osa/: fsl_sdmmc_osa.c fsl_sdmmc_osa.h
  group sdmmc/sd
    sdmmc/sd/: ChangeLogKSDK.txt
  group sdmmc/src
    sdmmc/src/: fsl_sd.c fsl_sdmmc_common.c
  group source
    source/: ffconf.h inter_cpu_communication.c main_cm33.c virtual_fs_api.c
  group utilities
    utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h
