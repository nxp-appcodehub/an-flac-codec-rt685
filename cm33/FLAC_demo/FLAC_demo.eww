<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\FLAC_demo.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>all</name>
            <member>
                <project>FLAC_demo</project>
                <configuration>release</configuration>
            </member>
            <member>
                <project>FLAC_demo</project>
                <configuration>debug</configuration>
            </member>
            <member>
                <project>FLAC_demo</project>
                <configuration>flash_debug</configuration>
            </member>
            <member>
                <project>FLAC_demo</project>
                <configuration>flash_release</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>release</name>
            <member>
                <project>FLAC_demo</project>
                <configuration>release</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>debug</name>
            <member>
                <project>FLAC_demo</project>
                <configuration>debug</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>flash_debug</name>
            <member>
                <project>FLAC_demo</project>
                <configuration>flash_debug</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>flash_release</name>
            <member>
                <project>FLAC_demo</project>
                <configuration>flash_release</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
